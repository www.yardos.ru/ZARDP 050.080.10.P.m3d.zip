# KOMPAS-3D part (ZARDP 050.080.10.P.m3d)

Model tree:
1. Операция без истории:1
